# IAR project Project.ewp, settings and files
configuration PY32F003x8_Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F003x8 Puya PY32F003x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: PY32F003x8; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\Drivers\BSP\PY32F003xx_Start_Kit; ..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f003x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PY32F003x7_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F003x7 Puya PY32F003x7
  ICCARM.CCDefines: PY32F003x7
  ICCARM.CCIncludePath2: ..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: py32f003x7_flash.icf
configuration PY32F003x6_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F003x6 Puya PY32F003x6
  ICCARM.CCDefines: PY32F003x6
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: py32f003x6_flash.icf
configuration PY32F003x4_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F003x4 Puya PY32F003x4
  ICCARM.CCDefines: PY32F003x4
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: py32f003x4_flash.icf
configuration PY32F003x3_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F003x3 Puya PY32F003x3
  ICCARM.CCDefines: PY32F003x3
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: py32f003x3_flash.icf
  group Doc
    ../: readme.txt
  group Drivers/BSP/PY32F003xx_Start_Kit
    ../../../Drivers/BSP/PY32F003xx_Start_Kit/: py32f003xx_ll_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32f0xx.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_exti.c py32f0xx_ll_gpio.c py32f0xx_ll_utils.c
  group Example/EWARM
    ./: startup_py32f003xx.s
  group Example/User
    ../Src/: bootloader.c flash.c main.c usart.c wdg.c
