# IAR project Project.ewp, settings and files
configuration PY32F403xD_Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F403xD Puya PY32F403xD
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F403xD; VECT_TAB_BASE=0x08000000
  ICCARM.CCIncludePath2: ..\..\..\Drivers\CMSIS\Device\PUYA\PY32F4xx\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\PY32F4xx_HAL_Driver\Inc; ..\Inc; ..\..\..\Drivers\BSP\PY32F403xx_Start_Kit; ..\..\..\Middlewares\Third_Party\CherryUSB\core; ..\..\..\Middlewares\Third_Party\CherryUSB\port; ..\..\..\Middlewares\Third_Party\CherryUSB\common; ..\..\..\Middlewares\Third_Party\CherryUSB\class\hid
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f403xD_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CherryUSB
    ../../../Middlewares/Third_Party/CherryUSB/port/: usb_dc_py32.c
    ../../../Middlewares/Third_Party/CherryUSB/core/: usbd_core.c
    ../../../Middlewares/Third_Party/CherryUSB/class/hid/: usbd_hid.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/PY32F403xx_Start_Kit
    ../../../Drivers/BSP/PY32F403xx_Start_Kit/: py32f403xx_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32f4xx.c
  group Drivers/PY32F4xx_HAL_Driver
    ../../../Drivers/PY32F4xx_HAL_Driver/Src/: py32f4xx_hal.c py32f4xx_hal_cortex.c py32f4xx_hal_dma.c py32f4xx_hal_gpio.c py32f4xx_hal_pwr.c py32f4xx_hal_pwr_ex.c py32f4xx_hal_rcc.c py32f4xx_hal_rcc_ex.c
  group Example/EWARM
    ./: startup_py32f403xx.s
  group Example/User
    ../Src/: app_bootloader.c app_flash.c app_i2c.c app_usart.c app_wdg.c main.c py32f4xx_hal_msp.c py32f4xx_it.c usbd_hid_inout_if.c
